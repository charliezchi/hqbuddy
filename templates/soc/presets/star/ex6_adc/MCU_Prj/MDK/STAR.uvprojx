# Keil uVision project STAR.uvprojx, settings and files
target STAR (6180000::V6.18::ARMCLANG)
  device: ARMCM33_DSP_FP_TZ ARM
  pack: ARM.CMSIS.5.9.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x20200000,0x00020000) IROM(0x00000000,0x00200000) IROM2(0x00200000,0x00200000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP TZ CLOCK(12000000) ESEL ELITTLE
  output: adc
  AfterMake: fromelf.exe #L --bin -o adc.bin
  AfterMake: mergeBinFileAndProgram.bat
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: __DSP_PRESENT,__FPU_PRESENT
  c include: ..\Lib\CMSIS\Device\StdPeriph_Driver\inc;..\Lib\CMSIS\Device\Include;..\Lib\CMSIS\Device\Source;..\Lib\CMSIS\Core\Include;..\User
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT5: ROM 0x200000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x20200000 size 0x20000
  group startup
    ../Lib/CMSIS/Device/Source/ARM/: startup_ARMCM33.s
  group lib
    ../Lib/CMSIS/Device/StdPeriph_Driver/src/: STAR_gpio.c STAR_rcc.c STAR_retarget.c STAR_uart.c STAR_adc.c
    ../Lib/CMSIS/Device/Source/: system_ARMCM33.c
  group user
    ../User/: main.c uart.c adc.c systick.c systick.h
