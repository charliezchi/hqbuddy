# Keil uVision project cm3_ahb_burst.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.5.9.0
  cpu: IROM(0x00000000,0x00040000) IRAM(0x20000000,0x00020000) CPUTYPE("Cortex-M3") CLOCK(12000000) ESEL ELITTLE
  output: cm3_ahb_burst
  AfterMake: $K\ARM\ARMCC\BIN\fromelf.exe #L --bin -o ahb_dma.bin
  AfterMake: mergeBinFileAndProgram.bat
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\Lib\CMSIS\Core\Include;..\Lib\CMSIS\Device\Include;..\Lib\CMSIS\Device\StdPeriph_Driver\inc;..\User
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group startup
    ../Lib/CMSIS/Device/Source/ARM/: startup_CM3DS.s
  group lib
    ../Lib/CMSIS/Device/StdPeriph_Driver/src/: CM3_retarget.c CM3DS_dma.c CM3DS_gpio.c CM3DS_rcc.c CM3DS_uart.c
    ../Lib/CMSIS/Device/Source/: system_CM3DS.c
  group user
    ../User/: DMA_AHB.c main.c uart.c
